Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-12-26T18:17:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Alternate UI 21.1.21.45
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 26 18:17:06 2025 * Host: HC0529 * Database: C:\Users\JAYDEE~1.MOD\AppData\Local\Temp\e49866e8-34c9-43d4-9a39-eae17b85cca4\b310a9ca-48d1-4428-8cf0-685acb0b762e\ifc * Database version: 5507 * Database creation date: Fri Dec 26 18:17:05 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 26 18:17:06 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 26 18:17:06 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcBuildingElementProxy: RF8.PPZ.3.SD:Standard, RF8.PPZ.3.SD:Standard:451782
In: Level 1
Type - Material: Glass, Metal_SKOPE_Stainless Steel_Satin
Type - Pset_BuildingElementProxyCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: SKOPE
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: Standard
Material: Metal_SKOPE_Stainless Steel_Satin, Plastic_SKOPE_Black, Glass, Plastic_SKOPE_White
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_451782
Description: Flow; FlowDirection: SOURCEANDSINK
